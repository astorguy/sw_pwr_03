R1 IN MID 1K
C1 COM MID 0.1U
R2 MID OUT 100
RLOAD OUT COM 100K
VCOM COM 0 0
* VIN IN 0 1
* PULSE (V1 V2 TD TR TF PW PER NP)
VIN IN 0 PULSE (0 10 0 3N 3N 100M)
.op
