R1 IN MID 1K
C1 COM MID 0.1U
R2 MID OUT 100
RLOAD OUT COM 100K
VCOM COM 0 0
* VIN IN 0 1
* PULSE (V1 V2 TD TR TF PW PER NP)
VIN IN 0 PULSE (0 10 0 3N 3N 100M)
.op
.control
* Timestamp: Fri Feb 2 04:00:32 2024
set wr_singlescale $ makes one x-axis for wrdata
set wr_vecnames $ puts names at top of columns
listing
op
print line all > /workspaces/sw_pwr_03/circuits/simple_rc/results/op1.txt
tran 1e-3 20e-3
wrdata /workspaces/sw_pwr_03/circuits/simple_rc/results/tr1.txt all
quit
.endc
