VIN IN 0 1
.op
